/dts-v1/;
/plugin/;
/ {
	compatible = "bcrm, bcm2835";
	fragment@0 {"
		target-path = "/";
		__overlay__ {
			my_device {
				compatible = "nxp,simtemp";
				sampling-ms = <100>;
				threshold-mC = <45000>;
				label = "Test";
			    	status = "okay";
			};
		};
	};
};
